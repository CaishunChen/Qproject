# Keil uVision project Project.uvprojx, settings and files
target PDF_Create&measure (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.2.1
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F072 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072
  c misc: --C99
  c include: ..\;..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F0xx_CPAL_Driver\inc;..\..\Libraries\CMSIS\Include;..\inc;..\src\PDFlib;..\..\Utilities\FatFs_v0.08b;..\src\Tem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group App
    ../src/: stm32_it.c main.c GetTime.C Lp_Mode.C spi_spiflash.c
    ../src/Tem/: 833et_table.c
  group STM32F0XX
    ../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group STM32F072_StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group FatFs
    ../../Utilities/FatFs_v0.08b/: diskio.c ff.c
  group PdfLib
    ../src/PDFlib/: pdf.c pdfApi.c
