# Keil uVision project Qproject.uvproj, settings and files
target Qproject (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Qproject
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_EMBEDDED_PHY,
  c include: .\App;.\FAT_FS\inc;.\STM32F4xx;.\STM32F4xx\inc;.\STM32F4xx\CMSIS\Include;.\STM32_EVAL;.\USB_Host;.\USB_Host\inc;.\USB_Host\STM32_USB_HOST_Library\Class\MSC\inc;.\USB_Host\STM32_USB_HOST_Library\Core\inc;.\USB_Host\STM32_USB_OTG_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./App/: main.c stm32fxxx_it.c usb_bsp.c usbh_usr.c PDF_Create.c
  group FAT_FS
    ./App/: fattime.c
    ./FAT_FS/src/: ff.c
  group STM32_EVAL
    ./STM32_EVAL/: lcd_log.c
  group STM32F4xx
    ./STM32F4xx/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
    ./STM32F4xx/src/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
    ./STM32F4xx/CMSIS/Source/Templates/arm/: startup_stm32f429_439xx.s
    ./App/: system_stm32f4xx.c
  group USB_Host
    ./USB_Host/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ./USB_Host/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./USB_Host/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
